Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2020-05-05T11:56:38
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190507_1515(x64) - Exporter 17.0.517.0 - Alternate UI 17.15.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue May 05 11:56:38 2020 * Host: DESKTOP-KN3O7NT * Database: C:\Users\SARAHS~1\AppData\Local\Temp\{D1A287E5-2939-41DB-8E8C-7DCE95B3B961}\ifc * Database version: 5507 * Database creation date: Tue May 05 11:56:32 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue May 05 11:56:32 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue May 05 11:56:32 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 0
LongName: Level 0; Elevation: 0 mm

# IfcBuildingElementProxy: Battery Pack Brushed Stainless Steel, Duten_SoapDpnsrs_S295:Battery Pack Brushed Stainless Steel:306044
In: Level 0
Type - PredefinedType: USERDEFINED; Classification: E2020200 Furniture & Accessories (Uniformat); Material: Duten_Metal_BrushedStainlessSteel, Duten_Plastic_Black
Pset_BuildingElementProxyCommon - Reference: n/a
Pset_ManufacturerTypeInformation - ModelReference: Transformer Brushed Stainless Steel; Manufacturer: Duten

# IfcBuildingElementProxy: Battery Pack Matte Black, Duten_SoapDpnsrs_S295:Battery Pack Matte Black:306085
In: Level 0
Type - PredefinedType: USERDEFINED; Classification: E2020200 Furniture & Accessories (Uniformat); Material: Duten_Metal_MatteBlack, Duten_Plastic_Black
Pset_BuildingElementProxyCommon - Reference: n/a
Pset_ManufacturerTypeInformation - ModelReference: Battery Pack Matte Black; Manufacturer: Duten

# IfcBuildingElementProxy: Battery Pack Polished Stainless Steel, Duten_SoapDpnsrs_S295:Battery Pack Polished Stainless Steel:306069
In: Level 0
Type - PredefinedType: USERDEFINED; Classification: E2020200 Furniture & Accessories (Uniformat); Material: Duten_Metal_Polished, Duten_Plastic_Black
Pset_BuildingElementProxyCommon - Reference: n/a
Pset_ManufacturerTypeInformation - ModelReference: Battery Pack Polished Stainless Steel; Manufacturer: Duten
